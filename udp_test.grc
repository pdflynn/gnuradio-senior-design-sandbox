options:
  parameters:
    generate_options: qt_gui
    id: udp_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/danny/development/gnuradio-sandbox/transmit_msg.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '12'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: '"127.0.0.1"'
    port: '40868'
    psize: '128'
    type: byte
    vlen: '1'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_udp_sink_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
