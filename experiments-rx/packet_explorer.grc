options:
  parameters:
    author: pdflynn
    generate_options: qt_gui
    id: sample_explorer
    output_language: python
    title: Sample Explorer for OTA TX
  states: {}

blocks:
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain [dB]
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: dum_enc
  id: variable_dummy_encoder_def
  parameters:
    framebits: '4128'
    ndim: '0'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 917e6
  states: {}
- name: hdr_const
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: hdr_dec
  id: variable_repetition_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
    prob: '0.5'
    rep: '3'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain [dB]
    rangeType: int
    start: '0'
    step: '2'
    stop: '40'
    value: '10'
  states: {}
- name: mark_delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '250'
    value: '34'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: preamble_select[int(1.0/hdr_dec.rate())]
  states: {}
- name: preamble_dummy
  id: variable
  parameters:
    comment: |-
      use when header
      FEC is Dummy
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: preamble_rep
  id: variable
  parameters:
    comment: |-
      use when header
      FEC is Repetition (x3)
    value: '[0xe3, 0x8f, 0xc0, 0xfc, 0x7f, 0xc7, 0xe3, 0x81, 0xc0, 0xff, 0x80, 0x38, 0xff, 0xf0, 0x38, 0xe0, 0x0f, 0xc0, 0x03, 0x80, 0x00, 0xff, 0xff, 0xc0]'
  states: {}
- name: preamble_select
  id: variable
  parameters:
    value: '{1: preamble_dummy, 3: preamble_rep}'
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(hdr_const, False, sps, True, eb, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {state: bypassed}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: mark_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: '0.999'
    threshold_method: digital.THRESHOLD_DYNAMIC
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: fc
    fftsize: '4096'
    gui_hint: tab1@0
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: fc
    fftsize: '4096'
    gui_hint: tab1@1
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab0@0
    size: '2048'
    srate: samp_rate
    type: complex
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab0@1
    marker1: '0'
    marker2: '0'
    size: '2048'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_start"'
    type: complex
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab0@2
    marker1: '0'
    size: '2048'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: corr_est
    type: float
    ymax: '200'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab0@3
    marker1: '0'
    marker2: '0'
    size: '2048'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: corr_est
    type: complex
    ymax: '200'
    ymin: '0'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: fc
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: bb_gain
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    label0: Raw Samples Time
    label1: Correlation Estimator
    label2: Correlation Estimate
    label3: Corr Est I/Q
    label4: Tab 4
    num_tabs: '5'
  states: {}
- name: tab1
  id: qtgui_tab_widget
  parameters:
    label0: Raw Samples FFT
    label1: Correlation Estimator
    label2: Correlation Estimate
    label3: Tab 3
    label4: Tab 4
    num_tabs: '5'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_correctiq_0, '0', digital_corr_est_cc_0, '0']
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_correctiq_0, '0', qtgui_time_sink_x_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_squared_0, '0']
- [digital_corr_est_cc_0, '1', qtgui_time_sink_x_0_0_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']
- [zeromq_sub_source_0, '0', digital_corr_est_cc_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
