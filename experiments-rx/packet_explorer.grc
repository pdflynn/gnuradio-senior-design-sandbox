options:
  parameters:
    author: pdflynn
    generate_options: qt_gui
    id: sample_explorer
    output_language: python
    title: Sample Explorer for OTA TX
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 917e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: fc
    fftsize: '4096'
    gui_hint: tab1@0
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab0@0
    size: '2048'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: fc
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    label0: Raw Samples Time
    label1: Tab 1
    label2: Tab 2
    label3: Tab 3
    label4: Tab 4
    num_tabs: '5'
  states: {}
- name: tab1
  id: qtgui_tab_widget
  parameters:
    label0: Raw Samples FFT
    label1: Tab 1
    label2: Tab 2
    label3: Tab 3
    label4: Tab 4
    num_tabs: '5'
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
