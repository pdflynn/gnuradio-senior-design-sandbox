options:
  parameters:
    category: Packet Operators
    generate_options: hb
    id: packet_tx_ota
    output_language: python
    title: OTA Packet TX
  states: {}

blocks:
- name: filt_delay
  id: variable
  parameters:
    value: int(1+(taps_per_filt-1)//2)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: taps_per_filt
  id: variable
  parameters:
    value: len(psf_taps)/nfilts
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    label: Bandwidth
    type: eng_float
    value: '0'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: hdr_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: pld_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: complex
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: packet_len
    post_padding: filt_delay*2
    pre_padding: '0'
    type: complex
    window: firdes.window(window.WIN_HANN, 20, 0)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: hdr_const.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: pld_const.points()
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: hdr_const.pre_diff_code()
  states: {}
- name: digital_map_bb_1_0
  id: digital_map_bb
  parameters:
    map: pld_const.pre_diff_code()
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: eb
  id: parameter
  parameters:
    label: Raised Cosine Rolloff
    type: eng_float
    value: '0'
  states: {}
- name: fec_async_encoder_0
  id: fec_async_encoder
  parameters:
    encoder: pld_enc
    mtu: '1500'
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {}
- name: fec_async_encoder_0_0
  id: fec_async_encoder
  parameters:
    encoder: hdr_enc
    mtu: '1500'
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {}
- name: hdr_const
  id: parameter
  parameters:
    label: Header constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: hdr_enc
  id: parameter
  parameters:
    label: Header FEC encoder
    value: ' fec.dummy_encoder_make(8000)'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: man_filt_delay
  id: parameter
  parameters:
    label: Manual Burst Padding
    type: eng_float
    value: '150'
  states: {}
- name: mod_header
  id: virtual_sink
  parameters:
    stream_id: Mod Header
  states: {}
- name: mod_payload
  id: virtual_sink
  parameters:
    stream_id: Mod Payload
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: postfec
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: postcrc
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: mux
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: burst
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: nfilts
    rrate: sps
    samp_delay: filt_delay
    taps: psf_taps
    type: ccf
  states: {}
- name: pld_const
  id: parameter
  parameters:
    label: Payload constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: pld_enc
  id: parameter
  parameters:
    label: Payload FEC encoder
    value: ' fec.dummy_encoder_make(8000)'
  states: {}
- name: psf_taps
  id: parameter
  parameters:
    label: Pulse Shape Filter
    value: '[0,]'
  states: {}
- name: rx_mod_header
  id: virtual_source
  parameters:
    stream_id: Mod Header
  states: {}
- name: rx_mod_payload
  id: virtual_source
  parameters:
    stream_id: Mod Payload
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: eng_float
    value: '2'
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', digital_map_bb_1, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_map_bb_1_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pad_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_tagged_stream_mux_0, '0', pad_sink_2, '0']
- [digital_burst_shaper_xx_0, '0', pad_sink_3, '0']
- [digital_burst_shaper_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', mod_header, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', mod_payload, '0']
- [digital_crc32_async_bb_1, out, fec_async_encoder_0, in]
- [digital_crc32_async_bb_1, out, pad_sink_1_0, in]
- [digital_map_bb_1, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_map_bb_1_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [digital_protocol_formatter_async_0, header, fec_async_encoder_0_0, in]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0, pdus]
- [fec_async_encoder_0, out, digital_protocol_formatter_async_0, in]
- [fec_async_encoder_0, out, pad_sink_1, in]
- [fec_async_encoder_0_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [pad_source_0, out, digital_crc32_async_bb_1, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_repack_bits_bb_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [rx_mod_header, '0', blocks_tagged_stream_mux_0, '0']
- [rx_mod_payload, '0', blocks_tagged_stream_mux_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
