options:
  parameters:
    author: Danny Flynn
    generate_options: qt_gui
    id: receiver_sim_hier
    output_language: python
    title: Packet Receiver Simulation
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_dummy_decoder_def_0
  id: variable_dummy_decoder_def
  parameters:
    framebits: '2048'
    ndim: '0'
  states: {}
- name: hdr_dec
  id: parameter
  parameters:
    label: Header FEC Decoder
    value: ' fec.dummy_decoder.make(8000)'
  states: {}
- name: packet_rx_0
  id: packet_rx
  parameters:
    eb: '0.35'
    hdr_const: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
    hdr_dec: hdr_dec
    hdr_format: digital.header_format_default(digital.packet_utils.default_access_code, 0)
    pld_const: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
    pld_dec: pld_dec
    psf_taps: '[0]'
    sps: '2'
  states: {}
- name: pld_dec
  id: parameter
  parameters:
    label: Payload FEC Decoder
    value: ' fec.dummy_decoder.make(8000)'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    legend: 'False'
    size: '1024'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    legend: 'False'
    size: '1024'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}

connections:
- [packet_rx_0, '0', qtgui_const_sink_x_0, '0']
- [packet_rx_0, '1', qtgui_const_sink_x_0_0, '0']
- [zeromq_sub_source_0, '0', packet_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
