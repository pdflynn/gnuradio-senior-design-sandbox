options:
  parameters:
    generate_options: qt_gui
    id: dvb_s2_tx_04_13
    output_language: python
    title: Senior Design Sim Test
  states: {}

blocks:
- name: const
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: default_header
  id: variable_header_format_default
  parameters:
    access_code: '0'
    bps: '1'
    threshold: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '500'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/danny/development/gnuradio-sandbox/transmit_msg.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '21'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: default_header
    len_tag_key: '"packet_len"'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: formatted_bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: formatted_bits
  states: {}

connections:
- [blocks_file_source_0, '0', digital_crc32_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_crc32_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
