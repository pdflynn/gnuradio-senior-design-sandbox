options:
  parameters:
    generate_options: qt_gui
    id: gmsk_no_fec
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '2'
  states: {}
- name: message_samp_rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_impairments_0
  id: channels_impairments
  parameters:
    freq_offset: '0'
    gamma: '0'
    i_ofs: '0'
    magbal: '0'
    phase_noise_mag: '-100'
    phasebal: '0'
    q_ofs: '0'
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C5_6
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: zeromq_req_msg_source_0
  id: zeromq_req_msg_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_throttle_1, '0', channels_impairments_0, '0']
- [channels_impairments_0, '0', qtgui_const_sink_x_0, '0']
- [channels_impairments_0, '0', qtgui_freq_sink_x_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', blocks_throttle_1, '0']
- [zeromq_req_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_req_source_0, '0', dtv_dvbs2_modulator_bc_0, '0']

metadata:
  file_format: 1
