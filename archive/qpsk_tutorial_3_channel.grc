options:
  parameters:
    generate_options: qt_gui
    id: qpsk_tutorial_1_simple
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Channel Frequency Offset
    orient: Qt.Horizontal
    start: '-100e-3'
    step: '1e-3'
    stop: '100e-3'
    value: '25e-3'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Channel Noise Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '.2'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,alpha,11*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: Channel Time Offset
    orient: Qt.Horizontal
    start: '.999'
    step: '100e-6'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/danny/development/gnuradio-sandbox/transmit_msg.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: TX
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: TX
    name: '"QPSK Modulation, alpha=0.25"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Re{TX}
    label2: Im{TX}
    size: '200'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
