options:
  parameters:
    author: danny
    generate_options: qt_gui
    id: wbfm_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate_0
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters: {}
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    digital_bandw_ch0: samp_rate_0
    digital_bandw_ch1: samp_rate_0
    oversample: '0'
    rf_freq: 100e6
    samp_rate: samp_rate_0
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_0
    fc: '0'
    fftsize: '1024'
    name: '"Audio"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [limesdr_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
