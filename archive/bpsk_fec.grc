options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '2'
  states: {}
- name: message_samp_rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: message_samp_rate
    type: byte
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_impairments_0
  id: channels_impairments
  parameters:
    freq_offset: '0'
    gamma: '0'
    i_ofs: '0'
    magbal: '0'
    phase_noise_mag: '-100'
    phasebal: '0'
    q_ofs: '0'
  states: {}
- name: digital_gmskmod_bc_0
  id: digital_gmskmod_bc
  parameters:
    L: '4'
    bt: '0.3'
    samples_per_symbol: '2'
  states: {}
- name: fec_generic_decoder_0
  id: fec_generic_decoder
  parameters:
    decoder: decoder_variable
  states: {}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: encoder_variable
    itype: byte
    otype: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_req_msg_source_0
  id: zeromq_req_msg_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', fec_generic_encoder_0, '0']
- [blocks_throttle_1, '0', channels_impairments_0, '0']
- [channels_impairments_0, '0', analog_quadrature_demod_cf_0, '0']
- [channels_impairments_0, '0', qtgui_const_sink_x_0, '0']
- [digital_gmskmod_bc_0, '0', blocks_throttle_1, '0']
- [fec_generic_encoder_0, '0', digital_gmskmod_bc_0, '0']
- [zeromq_req_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_req_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
